options:
  parameters:
    generate_options: qt_gui
    id: delayed_samples
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable_qtgui_chooser
  parameters:
    label: Channel
    labels: '[str(i) for i in range(11, 27)]'
    num_opts: '0'
    options: '[1000000 * (2400 + 5 * (i - 10)) for i in range(11, 27)]'
    type: real
    value: '2480000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '5000'
    type: complex
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("HELLO!\n")
    period: '2000'
  states: {}
- name: foo_packet_pad2_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: 2**16
    pad_front: '1000'
    pad_tail: '1000'
  states: {}
- name: ieee802_15_4_mac_0
  id: ieee802_15_4_mac
  parameters:
    debug: 'True'
    dst: '0xffff'
    dst_pan: '0xabcd'
    fcf: '0x9841'
    seq_nr: '0'
    src: '0x3344'
  states: {}
- name: ieee802_15_4_oqpsk_phy_1
  id: ieee802_15_4_oqpsk_phy
  parameters: {}
  states: {}
- name: ieee802_15_4_rime_stack_0
  id: ieee802_15_4_rime_stack
  parameters:
    bc_channels: '[129]'
    rime_add: '[24,42]'
    ruc_channels: '[132]'
    uc_channels: '[131]'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 400e6
    fc: freq
    fftsize: '1024'
    name: tx_sink
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_add_xx_0, '0', ieee802_15_4_oqpsk_phy_1, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '1']
- [blocks_message_strobe_0, strobe, ieee802_15_4_rime_stack_0, bcin]
- [foo_packet_pad2_0, '0', blocks_add_xx_0, '0']
- [foo_packet_pad2_0, '0', blocks_delay_0, '0']
- [ieee802_15_4_mac_0, app out, ieee802_15_4_rime_stack_0, fromMAC]
- [ieee802_15_4_mac_0, pdu out, ieee802_15_4_oqpsk_phy_1, txin]
- [ieee802_15_4_oqpsk_phy_1, '0', foo_packet_pad2_0, '0']
- [ieee802_15_4_oqpsk_phy_1, '0', qtgui_freq_sink_x_0, '0']
- [ieee802_15_4_oqpsk_phy_1, rxout, ieee802_15_4_mac_0, pdu in]
- [ieee802_15_4_rime_stack_0, toMAC, ieee802_15_4_mac_0, app in]

metadata:
  file_format: 1
